<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>langford_rx_dc</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>file</key><value>/dev/langford</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_short_to_float</key>
<param><key>id</key><value>gr_short_to_float_1</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250e6</value></param>
</block>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>gr_short_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_short_to_float_1</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
